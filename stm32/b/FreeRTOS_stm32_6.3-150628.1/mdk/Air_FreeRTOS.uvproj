# Keil uVision project Air_FreeRTOS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Air_FreeRTOS
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries;..\Libraries\inc;..\FreeRTOS\include;..\FreeRTOS\portable;..\User;..\FreeRTOS;..\bsp;..\bsp\delay;..\bsp\g7185;..\bsp\time;..\sys;..\src;..\task;..\bsp\uart;..\bsp\lcd;..\src\gui;..\src\kwjxt;..\include;..\bsp\w25x;..\driver\g7185;..\driver\lcd;..\driver\gsm;..\driver\w25x;..\driver\sim900a;..\driver\ev1527
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Libraries/: core_cm3.c
    ../Startup/: startup_stm32f10x_hd.s
  group FreeRTOS
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/: heap_2.c port.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../User/: main.c
    ../Libraries/: stm32f10x_it.c
  group bsp
    ../bsp/: bsp.c
    ../bsp/delay/: delay.c
    ../bsp/time/: sys_time.c
    ../bsp/uart/: sys_uart.c
  group src
    ../src/: MyString.c
  group sys
    ../sys/: msg_list.c my_list.c printp.c
  group task
    ../task/: input_task.c back_task.c gsm_task.c
  group driver
    ../driver/sim900a/: sim900a.c
    ../driver/ev1527/: ev1527.c
  group ff
    ../ff9/: diskio.c ff.c
    ../ff9/option/: cc936.c
